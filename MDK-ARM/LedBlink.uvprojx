# Keil uVision project LedBlink.uvprojx, settings and files
target n32l40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L402CB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IRAM2(0x20002000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\Application\inc;..\Driver\inc;..\firmware\CMSIS\device;..\firmware\n32l40x_algo_lib\inc;..\firmware\n32l40x_periph_lib\inc;..\firmware\n32l40x_std_periph_driver\inc;..\firmware\n32l40x_usbfs_driver\inc;..\Middleware\inc;..\firmware\CMSIS\core;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
  group firmware
    ../firmware/CMSIS/device/startup/: startup_n32l40x.s
    ../firmware/CMSIS/device/: system_n32l40x.c
    ../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group Application
    ../Application/src/: main.c n32l40x_it.c
  group Driver
    ../Driver/src/: systick.c led.c lazer.c
  group Common
    ../Common/src/: log.c
